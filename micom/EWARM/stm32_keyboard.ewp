# IAR project stm32_keyboard.ewp, settings and files
configuration stm32_keyboard (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RC ST STM32F401RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../USB_HOST/App; ../USB_HOST/Target; ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_keyboard.hex
  ILINK.IlinkOutputFile: stm32_keyboard.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
