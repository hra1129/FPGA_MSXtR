# Repository hra1129/FPGA_MSXtR

## KiCad design pcb/FPGA_MSXtR_Stack_SLOT2/StackSlot.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: 0.1uF; C_0402_1005Metric; LCSC C1525
C12: 100uF; C_1210_3225Metric; LCSC C49066
J5: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
J6: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
R1, R2, R3: 4.7K; R_0805_2012Metric
R4, R5, R6, R7, R8: 3.3K; R_0805_2012Metric
U1, U2: MSX SLOT
U3, U4, U5, U6, U7: SSOP-24_5.3x8.2mm_P0.65mm; LCSC C19197
U8: SO-14_3.9x8.65mm_P1.27mm

Connections:
3V3: C1.1, C3.1, C5.1, C7.1, C9.1, J5.39, R4.1, R5.1, R6.1, R7.1, R8.1, U3.1 (VCCA), U4.1 (VCCA), U4.2 (DIR), U5.1 (VCCA), U5.2 (DIR), U6.1 (VCCA), U6.2 (DIR), U7.1 (VCCA), U7.2 (DIR)
5V: C2.1, C4.1, C6.1, C8.1, C10.1, C11.1, C12.1, J6.35, R1.1, R2.1, R3.1, U1.45 (+5V), U1.47 (+5V), U2.45 (+5V), U2.47 (+5V), U3.23 (VCCB), U3.24 (VCCB), U4.23 (VCCB), U4.24 (VCCB), U5.23 (VCCB), U5.24 (VCCB), U6.23 (VCCB), U6.24 (VCCB), U7.23 (VCCB), U7.24 (VCCB), U8.14 (VCC)
+12V: J6.37, U1.48 (+12V), U2.48 (+12V)
-12V: J6.39, U1.50 (-12V), U2.50 (-12V)
A0: U1.28 (A0), U2.28 (A0), U5.21 (B1)
A1: U1.27 (A1), U2.27 (A1), U5.20 (B2)
A2: U1.30 (A2), U2.30 (A2), U4.15 (B7)
A3: U1.29 (A3), U2.29 (A3), U4.14 (B8)
A4: U1.32 (A4), U2.32 (A4), U4.17 (B5)
A5: U1.31 (A5), U2.31 (A5), U4.16 (B6)
A6: U1.22 (A6), U2.22 (A6), U5.15 (B7)
A7: U1.21 (A7), U2.21 (A7), U5.14 (B8)
A8: U1.24 (A8), U2.24 (A8), U5.17 (B5)
A9: U1.17 (A9), U2.17 (A9), U6.18 (B4)
A10: U1.20 (A10), U2.20 (A10), U6.21 (B1)
A11: U1.19 (A11), U2.19 (A11), U6.20 (B2)
A12: U1.23 (A12), U2.23 (A12), U5.16 (B6)
A13: U1.26 (A13), U2.26 (A13), U5.19 (B3)
A14: U1.25 (A14), U2.25 (A14), U5.18 (B4)
A15: U1.18 (A15), U2.18 (A15), U6.19 (B3)
D0: U1.34 (D0), U2.34 (D0), U3.15 (B7)
D1: U1.33 (D1), U2.33 (D1), U3.14 (B8)
D2: U1.36 (D2), U2.36 (D2), U3.17 (B5)
D3: U1.35 (D3), U2.35 (D3), U3.16 (B6)
D4: U1.38 (D4), U2.38 (D4), U3.19 (B3)
D5: U1.37 (D5), U2.37 (D5), U3.18 (B4)
D6: U1.40 (D6), U2.40 (D6), U3.21 (B1)
D7: U1.39 (D7), U2.39 (D7), U3.20 (B2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J5.40, J6.19, J6.20, J6.21, J6.23, J6.24, J6.25, J6.27, J6.28, U1.41 (GND), U1.43 (GND), U2.41 (GND), U2.43 (GND), U3.11 (GND), U3.12 (GND), U3.13 (GND), U4.4 (A2), U4.5 (A3), U4.6 (A4), U4.11 (GND), U4.12 (GND), U4.13 (GND), U5.11 (GND), U5.12 (GND), U5.13 (GND), U6.11 (GND), U6.12 (GND), U6.13 (GND), U7.11 (GND), U7.12 (GND), U7.13 (GND), U8.1 (1A), U8.3 (2A), U8.5 (3A), U8.7 (GND)
SLOT_A0: J6.4, U5.3 (A1)
SLOT_A1: J6.1, U5.4 (A2)
SLOT_A2: J6.6, U4.9 (A7)
SLOT_A3: J6.3, U4.10 (A8)
SLOT_A4: J6.8, U4.7 (A5)
SLOT_A5: J6.5, U4.8 (A6)
SLOT_A6: J5.22, U5.9 (A7)
SLOT_A7: J5.21, U5.10 (A8)
SLOT_A8: J5.24, U5.7 (A5)
SLOT_A9: J5.17, U6.6 (A4)
SLOT_A10: J5.20, U6.3 (A1)
SLOT_A11: J5.19, U6.4 (A2)
SLOT_A12: J5.23, U5.8 (A6)
SLOT_A13: J6.2, U5.5 (A3)
SLOT_A14: J5.25, U5.6 (A4)
SLOT_A15: J5.18, U6.5 (A3)
SLOT_BUSDIR_N: J5.10, R4.2, U8.12 (6Y)
SLOT_CLOCK_N: J6.18, U4.3 (A1)
SLOT_CS1_N: J5.1, U7.10 (A8)
SLOT_CS2_N: J5.2, U7.9 (A7)
SLOT_CS12_N: J5.3, U7.8 (A6)
SLOT_D0: J6.10, U3.9 (A7)
SLOT_D1: J6.7, U3.10 (A8)
SLOT_D2: J6.12, U3.7 (A5)
SLOT_D3: J6.9, U3.8 (A6)
SLOT_D4: J6.14, U3.5 (A3)
SLOT_D5: J6.11, U3.6 (A4)
SLOT_D6: J6.16, U3.3 (A1)
SLOT_D7: J6.13, U3.4 (A2)
SLOT_DATA_DIR: J5.26, U3.2 (DIR)
SLOT_INT_N: J5.8, R6.2, U8.8 (4Y)
SLOT_IORQ_N: J5.11, U7.3 (A1)
SLOT_M1_N: J5.9, U7.4 (A2)
SLOT_MERQ_N: J5.12, U6.10 (A8)
SLOT_OE2_N: J5.28, R8.2, U4.22 (OEn), U5.22 (OEn), U6.22 (OEn), U7.22 (OEn)
SLOT_OE_N: J5.16, R7.2, U3.22 (OEn)
SLOT_RD_N: J5.14, U6.8 (A6)
SLOT_RESET_N: J5.15, U6.7 (A5)
SLOT_RFSH_N: J5.6, U7.5 (A3)
SLOT_SLTSL1_N: J5.4, U7.7 (A5)
SLOT_SLTSL2_N: J5.5, U7.6 (A4)
SLOT_WAIT_N: J5.7, R5.2, U8.10 (5Y)
SLOT_WR_N: J5.13, U6.9 (A7)
SNDIN1: J6.22, U1.49 (SUNDIN)
SNDIN2: J6.26, U2.49 (SUNDIN)
/BUSDIR: R1.2, U1.10 (/BUSDIR), U2.10 (/BUSDIR), U8.13 (6A)
/CLOCK: U1.42 (CLOCK), U2.42 (CLOCK), U4.21 (B1)
/CS1: U1.1 (/CS1), U2.1 (/CS1), U7.14 (B8)
/CS2: U1.2 (/CS2), U2.2 (/CS2), U7.15 (B7)
/CS12: U1.3 (/CS12), U2.3 (/CS12), U7.16 (B6)
/INT: R3.2, U1.8 (/INT), U2.8 (/INT), U8.9 (4A)
/IORQ: U1.11 (/IORQ), U2.11 (/IORQ), U7.21 (B1)
/M1: U1.9 (/M1), U2.9 (/M1), U7.20 (B2)
/MERQ: U1.12 (/MERQ), U2.12 (/MERQ), U6.14 (B8)
/RD: U1.14 (/RD), U2.14 (/RD), U6.16 (B6)
/RESET: U1.15 (/RESET), U2.15 (/RESET), U6.17 (B5)
/RFSH: U1.6 (/RFSH), U2.6 (/RFSH), U7.19 (B3)
/SLTSL1: U1.4 (/SLTSL), U7.17 (B5)
/SLTSL2: U2.4 (/SLTSL), U7.18 (B4)
/WAIT: R2.2, U1.7 (/WAIT), U2.7 (/WAIT), U8.11 (5A)
/WR: U1.13 (/WR), U2.13 (/WR), U6.15 (B7)

Notes on the sheet:
SN74LVC8T245DBR 24SSOP
ラズパイ用スタッキングコネクターが使える
D[7:0] だけ特別な SLOT_OE_N を使う
SLOT_DATA_DIR 1: CPU → Cartridge (WRITE) 0: CPU ← Cartridge (READ)
SLOT1
SLOT2

Board: 2 copper layers, 95.0 x 95.0 mm, 32 parts (0 on the bottom side), 90 nets.

Other parts of the board:
G1: LOGO; msx_logo
G2: LOGO; usa

File pcb/FPGA_MSXtR_Stack_SLOT2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_3, _2, ",,3,,
"C1, C10, C11, C2, C3, C4, C5, C6, C7, C8, C9",0402,11,0.1uF,C1525
C12,1210,1,100uF,C49066
J5,PinHeader_2x20_P2.54mm_Vertical,1,MSX_EXBUS_B,
J6,PinHeader_2x20_P2.54mm_Vertical,1,MSX_EXBUS_A,
"R1, R2, R3",0805,3,4.7K,
"R4, R5, R6, R7, R8",0805,5,3.3K,
"U1, U2",MSX SLOT,2,~,
"U3, U4, U5, U6, U7",SSOP-24_5.3x8.2mm_P0.65mm,5,~,C19197
U8,SO-14_3.9x8.65mm_P1.27mm,1,~,

## KiCad design pcb/FPGA_MSXtR_Stack_CPU2/StackCPU.kicad_pcb

Parts:
C1, C3, C4, C7, C9: 0.1uF; C_0402_1005Metric; LCSC C1525
C2: 100uF; C_1210_3225Metric; LCSC C49066
C5: 1uF; C_0402_1005Metric; LCSC C1525
C6: 470uF; Capacitor(C453487)
C8: 15pF; C_0805_2012Metric; LCSC C63339
J1: Keybard I2C Connector; Grove_I2C
J2: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
J3: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
J4: Micro_SD_Card; MicroSD(C91145)
J5: USB_C_Receptacle_PowerOnly_6P; USB-C(C2927029)
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 3.3K; R_0402_1005Metric; LCSC C104350
R22, R23, R24, R25: 22K; R_0402_1005Metric
R26, R27: 100K; R_0402_1005Metric
R28, R29: 5.1K; R_0603_1608Metric
SW1: SW_MEC_5G; SideSW(C963235); LCSC C963235
SW2: SW_DIP_x04; DipSW4(C129043); LCSC C129043
SW3: SW_SPDT; Slide SW(C7431058); LCSC C7431058
U1: RaspberryPiPico2W
U2: TangPrimer25K(UPPER); LCSC C597938
U3, U5: ParallelROM_512KB; TSOP-I-32_11.8x8mm_P0.5mm
U4: TangPrimer25K(LOWER); LCSC C597938
U6: DCDC; DCDC_MAU108
U7: 28.63636MHz; CLOCK; LCSC C387408
U8: 8MB_Serial_SRAM; QSPI-SRAM 4Mbit (8SOIC); LCSC C139966

Connections:
+3V3: C1.1, C3.1, C4.1, C7.1, C9.1, J3.39, J4.4 (VDD), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, U2.2 (VCCIO2/3), U2.4 (VCCIO2/3), U2.46 (VDD_3V3), U2.48 (VDD_3V3), U2.50 (VDD_3V3), U3.8 (VCC), U4.84 (VCCIO0/1), U4.86 (VCCIO0/1), U4.89 (VCCIO6/7), U4.91 (VCCIO6/7), U5.8 (VCC), U7.1 (En), U7.4 (3V3), U8.8 (VCC)
+5V: C2.1, C5.1, C6.1, J1.3, J2.35, SW3.2 (B), U1.40 (VBUS), U2.52 (VDD_5V), U2.54 (VDD_5V), U2.56 (VDD_5V), U2.58 (VDD_5V), U2.60 (VDD_5V), U6.1 (+5V)
+12V: J2.37, R26.2, U6.6 (+12V)
-12V: J2.39, R27.1, U6.4 (-12V)
CLK28M: C8.1, U4.64 (CLK28M), U7.3 (CLK)
DIPSW0: SW2.1, U1.25 (GP19)
DIPSW1: SW2.2, U1.24 (GP18)
DIPSW2: SW2.3, U1.22 (GP17)
DIPSW3: SW2.4, U1.21 (GP16)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.4, J2.19, J2.20, J2.21, J2.23, J2.24, J2.25, J2.27, J2.28, J3.40, J4.6 (VSS), J5.A12 (GND), J5.B12 (GND), R26.1, R27.2, R28.2, R29.2, SW1.3 (B), SW1.4 (B), SW2.5, SW2.6, SW2.7, SW2.8, U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (GND), U1.38 (GND), U2.1 (GND), U2.19 (GND), U2.29 (GND), U2.35 (GND), U2.41 (GND), U2.47 (GND), U2.53 (GND), U2.59 (GND), U3.24 (GND), U4.61 (GND), U4.62 (GND), U4.75 (GND), U4.87 (GND), U4.88 (GND), U4.105 (GND), U4.110 (GND), U4.119 (GND), U4.120 (GND), U5.24 (GND), U6.2 (GND), U6.5 (COMMON), U7.2 (GND), U8.4 (VSS)
HS_CLK: J2.32, R9.1, U2.17 (HS_CLK)
HS_CS_N: J2.33, R20.1, U4.118 (HS_CS_N)
HS_READY: J2.30, R21.1, U4.112 (HS_READY)
HS_SIO0: J2.40, R10.1, U2.27 (HS_SIO0)
HS_SIO1: J2.38, R11.1, U2.25 (HS_SIO1)
HS_SIO2: J2.36, R12.1, U2.23 (HS_SIO2)
HS_SIO3: J2.34, R13.1, U2.21 (HS_SIO3)
I2C_SCL: J1.1, R8.2, U1.27 (GP21)
I2C_SDA: J1.2, R7.2, U1.26 (GP20)
MCU_CS_N: R14.1, U1.7 (FPGA_SPI_CS_N(GP5)), U2.28 (MCU_CS_N)
MCU_INTR: U1.5 (FPGA_SPI_INTR(GP3)), U2.36 (MCU_INTR)
MCU_MISO: J3.35, R16.1, U1.6 (FPGA_SPI_MISO(GP4)), U2.32 (MCU_MISO)
MCU_MOSI: J3.37, R15.1, U1.10 (FPGA_SPI_MOSI(GP7)), U2.30 (MCU_MOSI)
MCU_SCLK: J3.31, R17.1, U1.9 (FPGA_SPI_CLK(GP6)), U2.34 (MCU_SCLK)
unnamed: J5.A5 (CC1), R28.1
unnamed: J5.B5 (CC2), R29.1
unnamed: J5.A9 (VBUS), J5.B9 (VBUS), SW3.1 (A)
OSD_SPI_CS_N: J3.33, U1.4 (FPGA_OSD_SPI_CS_N(GP2))
RESET_BUTTON: SW1.1 (A), SW1.2 (A), U1.29 (GP22)
SD_SPI_CS_N: J4.2 (DAT3/CD), R22.1, U1.12 (SD_SPI_CS_N(GP9))
SD_SPI_MISO: J4.7 (DAT0), R25.1, U1.11 (SD_SPI_MISO(GP8))
SD_SPI_MOSI: J4.3 (CMD), R23.1, U1.15 (SD_SPI_MOSI(GP11))
SD_SPI_SCK: J4.5 (CLK), R24.1, U1.14 (SD_SPI_SCK(GP10))
SLOT_A0: J2.4, U3.20 (A0), U4.93 (SLOT_A0), U5.20 (A0)
SLOT_A1: J2.1, U3.19 (A1), U4.95 (SLOT_A1), U5.19 (A1)
SLOT_A2: J2.6, U3.18 (A2), U4.97 (SLOT_A2), U5.18 (A2)
SLOT_A3: J2.3, U3.17 (A3), U4.99 (SLOT_A3), U5.17 (A3)
SLOT_A4: J2.8, U3.16 (A4), U4.101 (SLOT_A4), U5.16 (A4)
SLOT_A5: J2.5, U3.15 (A5), U4.103 (SLOT_A5), U5.15 (A5)
SLOT_A6: J3.22, U3.14 (A6), U4.72 (SLOT_A6), U5.14 (A6)
SLOT_A7: J3.21, U3.13 (A7), U4.70 (SLOT_A7), U5.13 (A7)
SLOT_A8: J3.24, U3.3 (A8), U4.76 (SLOT_A8), U5.3 (A8)
SLOT_A9: J3.17, U3.2 (A9), U4.73 (SLOT_A9), U5.2 (A9)
SLOT_A10: J3.20, U3.31 (A10), U4.68 (SLOT_A10), U5.31 (A10)
SLOT_A11: J3.19, U3.1 (A11), U4.66 (SLOT_A11), U5.1 (A11)
SLOT_A12: J3.23, U3.12 (A12), U4.74 (SLOT_A12), U5.12 (A12)
SLOT_A13: J2.2, U4.80 (SLOT_A13)
SLOT_A14: J3.25, U4.78 (SLOT_A14)
SLOT_A15: J3.18, U4.83 (SLOT_A15)
SLOT_BUSDIR: J3.10, U2.24 (SLOT_BUSDIR)
SLOT_CLOCK_N: J2.18, U4.90 (SLOT_CLOCK_N)
SLOT_CS1_N: J3.1, U2.6 (SLOT_CS1_N)
SLOT_CS2_N: J3.2, U2.8 (SLOT_CS2_N)
SLOT_CS12_N: J3.3, U2.10 (SLOT_CS12_N)
SLOT_D0: J2.10, U3.21 (D0), U4.94 (SLOT_D0), U5.21 (D0)
SLOT_D1: J2.7, U3.22 (D1), U4.96 (SLOT_D1), U5.22 (D1)
SLOT_D2: J2.12, U3.23 (D2), U4.98 (SLOT_D2), U5.23 (D2)
SLOT_D3: J2.9, U3.25 (D3), U4.100 (SLOT_D3), U5.25 (D3)
SLOT_D4: J2.14, U3.26 (D4), U4.102 (SLOT_D4), U5.26 (D4)
SLOT_D5: J2.11, U3.27 (D5), U4.104 (SLOT_D5), U5.27 (D5)
SLOT_D6: J2.16, U3.28 (D6), U4.106 (SLOT_D6), U5.28 (D6)
SLOT_D7: J2.13, U3.29 (D7), U4.108 (SLOT_D7), U5.29 (D7)
SLOT_DATA_DIR: J3.26, U4.82 (SLOT_DATA_DIR)
SLOT_INT_N: J3.8, U2.20 (SLOT_INT_N)
SLOT_IORQ_N: J3.11, U2.26 (SLOT_IORQ_N)
SLOT_M1_N: J3.9, U2.22 (SLOT_M1_N)
SLOT_MA13: U3.4 (A13), U4.107 (SLOT_MA13), U5.4 (A13)
SLOT_MA14: U3.5 (A14), U4.109 (SLOT_MA14), U5.5 (A14)
SLOT_MA15: U3.11 (A15), U4.111 (SLOT_MA15), U5.11 (A15)
SLOT_MA16: U3.10 (A16), U4.113 (SLOT_MA16), U5.10 (A16)
SLOT_MA17: U3.6 (A17), U4.115 (SLOT_MA17), U5.6 (A17)
SLOT_MA18: U3.9 (A18), U4.117 (SLOT_MA18), U5.9 (A18)
SLOT_MERQ_N: J3.12, U4.63 (SLOT_MERQ_N)
SLOT_OE2_N: J3.28, U4.92 (SLOT_OE2_N)
SLOT_OE_N: J3.16, U4.71 (SLOT_OE_N)
SLOT_RD_N: J3.14, U3.32 (/OE), U4.67 (SLOT_RD_N), U5.32 (/OE)
SLOT_RESET_N: J3.15, U4.69 (SLOT_RESET_N)
SLOT_RFSH_N: J3.6, U2.16 (SLOT_RFSH_N)
SLOT_ROM0_CE_N: R18.1, U3.30 (/CE), U4.114 (SLOT_ROM0_CE_N)
SLOT_ROM1_CE_N: R19.1, U4.116 (SLOT_ROM1_CE_N), U5.30 (/CE)
SLOT_SLTSL1_N: J3.4, U2.12 (SLOT_SLTSL1_N)
SLOT_SLTSL2_N: J3.5, U2.14 (SLOT_SLTSL2_N)
SLOT_WAIT_N: J3.7, U2.18 (SLOT_WAIT_N)
SLOT_WR_N: J3.13, U3.7 (/WE), U4.65 (SLOT_WR_N), U5.7 (/WE)
SRAM_CS_N: R6.2, U2.5 (SRAM_CS_N), U8.1 (~CS)
SRAM_SCLK: R5.2, U2.7 (SRAM_SCLK), U8.6 (SCK)
SRAM_SIO0: R1.2, U2.9 (SRAM_SIO0), U8.5 (SI/SIO0)
SRAM_SIO1: R2.2, U2.11 (SRAM_SIO1), U8.2 (SO/SIO1)
SRAM_SIO2: R3.2, U2.15 (SRAM_SIO2), U8.3 (SIO2)
SRAM_SIO3: R4.2, U2.3 (SRAM_SIO3), U8.7 (~HOLD/SIO3)

Notes on the sheet:
ラズパイ用スタッキングコネクターが使える
LCSC Part#C91145 Micro SD Card Slot
MSX_EXBUS_B
LCSC Part#C7431058 Slide SW
https://akizukidenshi.com/catalog/g/g104134/ DCDC±12V MAU108
SLOT_SNDIN2
MSXtR PICO
LCSC Part#C19941161 Flash ROM 4Mbit System ROM SST39VF040-70
MCU_* は、Pico から CPU Board を制御する SPI。 OSD_* は、Pico から VDP Board の OSD を制御する SPI。 SPI 信号自体は共通であり、CS が分かれている。排他制御。
LCSC Part#C139966 SystemRAM 64Mbit
LCSC Part#C453487 C
LCSC Part#C963235 Side Tactile Button
LCSC Part# C1525 0.1uF
LCSC Part# C129043 x4 switch
DAT0(DO) - MISO CMD(DI) - MOSI
SLOT_SNDIN1
LCSC Part# C2901579 CLOCK 28.63636MHz
LCSC Part#C2927029 USB-C Connector
LCSC Part# C63339 15pF
LCSC Part#C43651917 Flash ROM 4Mbit Extend ROM (OPTION) SST39VF040-70
POWER SW

Board: 2 copper layers, 95.0 x 95.0 mm, 56 parts (0 on the bottom side), 90 nets.

Other parts of the board:
G1: LOGO; msx_logo
G2: LOGO; usa

File pcb/FPGA_MSXtR_Stack_CPU2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C4, C7, C9",0402,5,0.1uF,C1525
C2,1210,1,100uF,C49066
C5,0402,1,1uF,C1525
C6,Capacitor(C453487),1,470uF,
C8,0805,1,15pF,C63339
J1,Grove_I2C,1,Keybard I2C Connector,
J2,PinHeader_2x20_P2.54mm_Vertical,1,MSX_EXBUS_A,
J3,PinHeader_2x20_P2.54mm_Vertical,1,MSX_EXBUS_B,
J4,MicroSD(C91145),1,Micro_SD_Card,
J5,USB-C(C2927029),1,USB_C_Receptacle_PowerOnly_6P,
"R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R3, R4, R5, R6, R7, R8, R9",0402,21,3.3K,C104350
"R22, R23, R24, R25",0402,4,22K,
"R26, R27",0402,2,100K,
"R28, R29",0603,2,5.1K,
SW1,SideSW(C963235),1,SW_MEC_5G,C963235
SW2,DipSW4(C129043),1,SW_DIP_x04,C129043
SW3,Slide SW(C7431058),1,SW_SPDT,C7431058
U1,RaspberryPiPico2W,1,~,
U2,TangPrimer25K(UPPER),1,~,C597938
"U3, U5",TSOP-I-32_11.8x8mm_P0.5mm,2,~,
U4,TangPrimer25K(LOWER),1,~,C597938
U6,DCDC_MAU108,1,~,
U7,CLOCK,1,~,C387408
U8,QSPI-SRAM 4Mbit (8SOIC),1,~,C27585175

Notices in the files:
pcb/FPGA_MSXtR_Stack_CPU2/StackCPU.kicad_pcb:
Copyright (C)2026 HRA!
