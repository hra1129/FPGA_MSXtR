; ============================================================================
;	zt_engine.asm
;	CPU test : z80test ( https://github.com/raxoft/z80test ) engine port
;
;	Port of idea.asm of z80test by Patrik Rak (MIT license, see
;	z80test/license.txt).  The test vector combinator and the CRC update are
;	kept exactly as the original, only the following points are changed:
;		- relocated to ZT_BASE (page 3 RAM), the data page follows the code
;		- the CRC table is generated by zt_init instead of being included
;		- OUT (0FEh) for the Spectrum MIC bit is removed
;		- a progress spinner is updated every 256 combinations
;
;	The including file defines:
;		ZT_BASE      : load address
;		ZT_MASKFLAGS : 1 = only documented flags are checked
;		ZT_ONLYFLAGS : 1 = only flags are checked (registers are ignored)
;		ZT_POSTCCF   : 1 = CCF is executed after each instruction tested
;		ZT_MEMPTR    : 1 = BIT 0,(HL) is executed after each instruction tested
;		ZT_SPIN      : 1 = progress spinner is enabled
;
;	This binary is executed both on the MSX and on the Python Z80 model
;	(make_tests.py), the expected CRCs are calculated with the same code.
; ============================================================================

ZT_OPSIZE		:= 4 + ZT_POSTCCF
ZT_DATASIZE		:= 16
ZT_VECSIZE		:= ZT_OPSIZE + ZT_DATASIZE

ZT_SPIN_VRAM	:= 0x1800 + 32 + 31

			org		ZT_BASE
; ----------------------------------------------------------------------------
;	header
; ----------------------------------------------------------------------------
zt_header:
			dw		zt_init						; +0
			dw		zt_test						; +2
			dw		zt_data						; +4  ( mem = +12, jmp = +16 )
			dw		zt_opcode					; +6  ( self )
			defb	ZT_OPSIZE					; +8
			defb	ZT_VECSIZE					; +9
			dw		zt_crctable					; +10
			dw		zt_end						; +12

; ----------------------------------------------------------------------------
;	zt_init
;	Build the CRC-32 table ( polynomial 0EDB88320h, 4 pages, LSB first ).
; ----------------------------------------------------------------------------
zt_init:
			ld		hl, zt_crctable
zt_init_loop:
			ld		e, l
			ld		d, 0
			ld		c, 0
			ld		b, 0
			ld		a, 8
zt_init_bit:
			srl		b
			rr		c
			rr		d
			rr		e
			jr		nc, zt_init_next
			push	af
			ld		a, b
			xor		a, 0xED
			ld		b, a
			ld		a, c
			xor		a, 0xB8
			ld		c, a
			ld		a, d
			xor		a, 0x83
			ld		d, a
			ld		a, e
			xor		a, 0x20
			ld		e, a
			pop		af
zt_init_next:
			dec		a
			jr		nz, zt_init_bit
			ld		[hl], e
			inc		h
			ld		[hl], d
			inc		h
			ld		[hl], c
			inc		h
			ld		[hl], b
			dec		h
			dec		h
			dec		h
			inc		l
			jr		nz, zt_init_loop
			xor		a, a
			ld		[zt_spin_cnt], a
			ld		[zt_spin_idx], a
			ret

; ----------------------------------------------------------------------------
;	zt_test
;	input:
;		hl ... test record ( flag mask, base vector, counter, shifter )
;	output:
;		bcde ... CRC-32 ( b = MSB )
; ----------------------------------------------------------------------------
zt_test:
			ld		[zt_spptr + 1], sp

			if ZT_MASKFLAGS
				ld		a, [hl]
				ld		[zt_flagptr + 1], a
			endif

			inc		hl

			ld		de, zt_vector
			ld		bc, ZT_VECSIZE
			call	zt_copy

			add		hl, bc

			call	zt_copy

			call	zt_copy

			add		hl, bc

			ld		[zt_valptr + 1], de

			inc		de

			call	zt_clear

			ld		[zt_maskptr + 1], de

			xor		a, a
			ld		[de], a
			inc		de

			call	zt_copy

			ld		a, 0xA9
			ld		i, a
			ld		r, a
			or		a, a
			ex		af, af'

			ld		bc, 65535
			ld		d, b
			ld		e, c
			exx

			ld		sp, zt_data

; test vector sequence combinator
zt_loop:
			ld		hl, zt_counter
			ld		de, zt_shifter + 1
			ld		bc, zt_vector

			ld		a, [bc]
			xor		a, [hl]
			ex		de, hl
			xor		a, [hl]
			cp		a, 0x76						; skip halt
			jp		z, zt_next
			ld		[zt_opcode], a
			inc		c
			inc		e
			inc		l

			ld		a, [bc]
			xor		a, [hl]
			ex		de, hl
			xor		a, [hl]
			ld		[zt_opcode + 1], a
			cp		a, 0x76						; skip halt...
			jp		nz, zt_ok
			ld		a, [zt_opcode]
			and		a, 0xDF						; ... with IX/IY prefix
			cp		a, 0xDD
			jp		z, zt_next
zt_ok:
			inc		c
			inc		e
			inc		l

			repeat	i, ZT_OPSIZE - 2
				ld		a, [bc]
				xor		a, [hl]
				ex		de, hl
				xor		a, [hl]
				ld		[zt_opcode + 2 + i], a
				inc		c
				inc		e
				inc		l
			endr

			repeat	i, ZT_DATASIZE
				ld		a, [bc]
				xor		a, [hl]
				ex		de, hl
				xor		a, [hl]
				ld		[zt_data + i], a
				if i < ZT_DATASIZE - 1
					inc		c
					inc		e
					inc		l
				endif
			endr

; the test itself
			pop		af
			pop		bc
			pop		de
			pop		hl
			pop		ix
			pop		iy
			ld		sp, [zt_data_sp]

zt_opcode:
			space	ZT_OPSIZE, 0
zt_continue:
			if ZT_MEMPTR
				ld		hl, zt_data
				bit		0, [hl]
			endif

			ld		[zt_data_sp], sp
			ld		sp, zt_regstop
			push	iy
			push	ix
			push	hl
			push	de
			push	bc
			push	af

			ld		hl, zt_data

			if ZT_MASKFLAGS
				ld		a, [hl]
zt_flagptr:
				and		a, 0xFF
				if ZT_ONLYFLAGS == 0
					ld		[hl], a
				endif
			endif

; CRC update
			if ZT_ONLYFLAGS == 0
				ld		b, ZT_DATASIZE
			endif

zt_crcloop:
			if ( ZT_ONLYFLAGS & ZT_MASKFLAGS ) == 0
				ld		a, [hl]
			endif

			exx
			xor		a, e

			ld		l, a
			ld		h, zt_crctable >> 8

			ld		a, [hl]
			xor		a, d
			ld		e, a
			inc		h

			ld		a, [hl]
			xor		a, c
			ld		d, a
			inc		h

			ld		a, [hl]
			xor		a, b
			ld		c, a
			inc		h

			ld		b, [hl]

			exx

			if ZT_ONLYFLAGS == 0
				inc		hl
				djnz	zt_crcloop
			endif

; multibyte counter with arbitrary bit mask
zt_next:
			if ZT_SPIN
				ld		hl, zt_spin_cnt
				dec		[hl]
				jp		nz, zt_next_count
				ld		a, [zt_spin_idx]
				inc		a
				and		a, 3
				ld		[zt_spin_idx], a
				ld		l, a
				ld		h, 0
				ld		bc, zt_spin_chars
				add		hl, bc
				ld		a, ZT_SPIN_VRAM & 0xFF
				out		[0x99], a
				ld		a, ( ZT_SPIN_VRAM >> 8 ) | 0x40
				out		[0x99], a
				ld		a, [hl]
				out		[0x98], a
zt_next_count:
			endif
			ld		hl, zt_countmask
			ld		de, zt_counter
			ld		b, ZT_VECSIZE
zt_countloop:
			ld		a, [de]
			or		a, a
			jr		z, zt_countnext
			dec		a
			and		a, [hl]
			ld		[de], a
			jp		zt_loop
zt_countnext:
			ld		a, [hl]
			ld		[de], a
			inc		l
			inc		e
			djnz	zt_countloop

; multibyte shifter with arbitrary bit mask
zt_maskptr:
			ld		hl, zt_shiftmask
zt_valptr:
			ld		de, zt_shifter
			ld		a, [de]
			add		a, a
			neg
			add		a, [hl]
			xor		a, [hl]
			and		a, [hl]
			ld		[de], a
			jp		nz, zt_loop
zt_shiftloop:
			inc		l
			inc		e
			ld		a, e
			cp		a, zt_shiftend & 0xFF
			jr		z, zt_exit
			ld		a, [hl]
			dec		a
			xor		a, [hl]
			and		a, [hl]
			jr		z, zt_shiftloop
			ld		[de], a
			ld		[zt_maskptr + 1], hl
			ld		[zt_valptr + 1], de
			jp		zt_loop

zt_exit:
			exx
zt_spptr:
			ld		sp, 0
			ret

; misc helper routines
zt_copy:
			push	hl
			push	bc
			ldir
			pop		bc
			pop		hl
			ret

zt_clear:
			push	hl
			push	bc
			ld		h, d
			ld		l, e
			ld		[hl], 0
			inc		de
			dec		bc
			ldir
			pop		bc
			pop		hl
			ret

zt_spin_chars:
			defb	"-/|*"

; ----------------------------------------------------------------------------
;	data page ( the whole workspace must be kept within a single 256 byte page )
; ----------------------------------------------------------------------------
			space	( 256 - ( $ & 255 ) ) & 255, 0
zt_data:
			space	ZT_DATASIZE - 4, 0
zt_regstop:
zt_data_mem:
			space	2, 0
zt_data_sp:
			space	2, 0
zt_jump:
			if ZT_POSTCCF
				ccf
			else
				inc		bc
			endif
			jp		zt_continue

zt_vector:
			space	ZT_VECSIZE, 0
zt_counter:
			space	ZT_VECSIZE, 0
zt_countmask:
			space	ZT_VECSIZE, 0
zt_shifter:
			space	1 + ZT_VECSIZE, 0
zt_shiftend:
zt_shiftmask:
			space	1 + ZT_VECSIZE, 0
zt_spin_cnt:
			defb	0
zt_spin_idx:
			defb	0
zt_end:
			if ( zt_end - 1 ) >> 8 != zt_data >> 8
				error "zt workspace crosses a page"
			endif

; CRC table ( generated by zt_init, 1KB, not included in the binary )
zt_crctable		:= ( zt_end + 255 ) & 0xFF00
